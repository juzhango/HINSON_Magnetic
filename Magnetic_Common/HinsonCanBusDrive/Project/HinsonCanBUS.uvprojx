# Keil uVision project HinsonCanBUS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ros_stm32f407 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,__32BIT_IO_2BOARD__
  c misc: --cpp
  c include: ..\..\Prj_Comm\Common;..\..\Prj_Comm\Main;..\..\Prj_Comm\Startup_config;..\..\Prj_Comm\STM32F4_FWLIB\inc;..\..\Prj_Comm\TeamRobot_Drive;..\..\Prj_Comm\USER;..\..\Prj_Comm\UCOSII;..\..\Prj_Comm\UCOSII\CONFIG;..\..\Prj_Comm\UCOSII\CORE;..\..\Prj_Comm\UCOSII\PORT;..\..\Prj_Comm\ros_lib;..\User;..\User;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main
    ../../Prj_Comm/Main/: main.c stm32f4xx_it.c
  group Startup_config
    ../../Prj_Comm/Startup_config/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group STM32F4_FWLIB
    ../../Prj_Comm/STM32F4_FWLIB/src/: STM32F4_FWLIB.lib
  group TeamRobot_Drive
    ../../Prj_Comm/TeamRobot_Drive/: TeamRobot_Drive.h TeamRobot_Drive.lib
  group USER
    ../User/src/: multi_thread.c AGV_CANBUS_HINSON_MGS160N.c AGV_Can1_Msg_Receive.c usart3_user.c
  group Common
    ../../Prj_Comm/Common/: Common.lib
  group UCOSII_LIB
    ../../Prj_Comm/UCOSII/: UCOSII_LIB.h UCOSII.lib
  group Ros_lib
    ../../Prj_Comm/ros_lib/: Ros_lib.lib
software components: CMSIS:CORE 5.1.1
